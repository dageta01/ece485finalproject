# Keil uVision project tictactoe.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtx_blinky_ind
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group Board Support
    ./src/: led_mcb1700.c
    ./: GLCD_SPI_LPC1700.c mcb1700_joystick.c
  group CMSIS
    ./src/: rtx_conf_cm.c
    ./lib/: RTX_CM3.lib
  group Device
    ./startup/: system_lpc17xx.c startup_lpc17xx.s
    ./src/: gpio_lpc17xx.c pin_lpc17xx.c
